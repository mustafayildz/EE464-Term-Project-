# Altium schematic sheet Push.~(3).SchDoc
size A4; SheetNumber: 1; SheetTotal: 1

## Parts
*  Component_1  [transformer]